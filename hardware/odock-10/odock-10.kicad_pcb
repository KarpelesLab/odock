# Repository KarpelesLab/odock (continued)

## KiCad design hardware/odock-10/odock-10.kicad_pcb (continued)

Schematic: usb_hub.kicad_sch, odock-10 — USB 3.2 Gen2 hub (USB7206C)

Parts:
C601, C602, C603, C604, C605, C606, C607, C608, C609, C610, C611, C612: 220n; C_0402_1005Metric; LCSC C16772
C613, C614, C615, C616, C617, C618, C619, C620, C624, C625, C626, C627, C628, C629, C630, C631, C632, C641: 100n; C_0402_1005Metric; LCSC C1525
C621, C622, C633, C634, C635: 4.7u; C_0402_1005Metric; LCSC C23733
C623, C636, C639: 1n; C_0402_1005Metric; LCSC C1523
C637, C638: 20p; C_0402_1005Metric; LCSC C1554
C640: 100n; C_0402_1005Metric; LCSC C1525; not fitted
D601, D602: BAT54WS; D_SOD-323; LCSC C124205
R601: 12k; R_0402_1005Metric; LCSC C25752
R602, R603, R604, R605, R609, R624, R627, R628: 10k; R_0402_1005Metric; LCSC C25744
R606, R607, R608: 200k; R_0402_1005Metric; LCSC C25764
R610, R611, R612, R613, R615, R616, R617, R618, R619, R620, R621, R622, R623: 100k; R_0402_1005Metric; LCSC C25741
R614: 10k; R_0402_1005Metric; LCSC C25744; not fitted
R625: 47k; R_0402_1005Metric; LCSC C25792
R626: 68k; R_0603_1608Metric; LCSC C23231
R629: 4.7k; R_0402_1005Metric; LCSC C25900
R630, R631: 0; R_0402_1005Metric; LCSC C17168
R632: 15k; R_0402_1005Metric; LCSC C25756
R633: 49.9k; R_0603_1608Metric; LCSC C23184
U601: USB7206CT/KDX; VQFN-100_L12.0-W12.0-P0.40-TL-EP8.0; MPN USB7206CT/KDX; LCSC C3210691
U602: SST26VF016B; SOP-8_L4.9-W3.9-P1.27-LS6.0-BL; MPN SST26VF016B-104I/SN; LCSC C631790; not fitted
U603: 74LVC1G17; SOT-23-5; MPN 74LVC1G17W5-7; LCSC C151394
Y601: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9006

Connections:
+1V15: C624.1, C625.1, C626.1, C627.1, C628.1, C629.1, C630.1, C631.1, C632.1, C633.1, C634.1, C635.1, C636.1, U601.9 (VCORE), U601.18 (VCORE), U601.25 (VCORE), U601.31 (VCORE), U601.38 (VCORE), U601.55 (VCORE), U601.78 (VCORE), U601.85 (VCORE), U601.93 (VCORE); also elsewhere on the board
+3V3: C613.1, C614.1, C615.1, C616.1, C617.1, C618.1, C619.1, C620.1, C621.1, C622.1, C623.1, C640.1, C641.1, D602.1 (K), R602.2, R603.2, R604.2, R608.2, R609.2, R614.2, R624.2, U601.26 (VDD33), U601.43 (VDD33), U601.53 (VDD33), U601.62 (VDD33), U601.67 (VDD33), U601.79 (VDD33), U601.88 (VDD33), U601.99 (VDD33), U602.8 (VDD), U603.5 (VCC); also elsewhere on the board
/USB hub/HUB_CFG1: R605.1, U601.21 (~CFG_STRAP1)
/USB hub/HUB_CFG2: R606.1, U601.22 (~CFG_STRAP2)
/USB hub/HUB_CFG3: R607.1, U601.23 (~CFG_STRAP3)
/USB hub/HUB_P1_TXN_IC: C604.1, U601.8 (USB3DN_TXDM1)
/USB hub/HUB_P1_TXP_IC: C603.1, U601.7 (USB3DN_TXDP1)
/USB hub/HUB_P2_TXN_IC: C606.1, U601.17 (USB3DN_TXDM2)
/USB hub/HUB_P2_TXP_IC: C605.1, U601.16 (USB3DN_TXDP2)
/USB hub/HUB_P3_TXN_IC: C608.1, U601.30 (USB3DN_TXDM3)
/USB hub/HUB_P3_TXP_IC: C607.1, U601.29 (USB3DN_TXDP3)
/USB hub/HUB_P4_TXN_IC: C610.1, U601.37 (USB3DN_TXDM4)
/USB hub/HUB_P4_TXP_IC: C609.1, U601.36 (USB3DN_TXDP4)
/USB hub/HUB_P5_TXN_IC: C612.1, U601.84 (USB3DN_TXDM5)
/USB hub/HUB_P5_TXP_IC: C611.1, U601.83 (USB3DN_TXDP5)
/USB hub/HUB_PF3: R615.1, U601.44 (PF3)
/USB hub/HUB_PF4: R616.1, U601.45 (PF4)
/USB hub/HUB_PF5: R617.1, U601.46 (PF5)
/USB hub/HUB_PF6: R618.1, U601.47 (PF6)
/USB hub/HUB_PF7: R619.1, U601.48 (PF7)
/USB hub/HUB_PF18: R620.1, U601.61 (PF18)
/USB hub/HUB_PF19: R621.1, U601.66 (PF19)
/USB hub/HUB_PF29: R623.1, U601.74 (PF29)
/USB hub/HUB_PF31: R622.1, U601.3 (PF31)
/USB hub/HUB_RBIAS: R601.1, U601.100 (RBIAS)
/USB hub/HUB_SPI_CE_N: R608.1, U601.69 (SPI_CE_N/~CFG_NON_REM/PF20), U602.1 (~CE)
/USB hub/HUB_SPI_CLK: R610.1, U601.68 (SPI_CLK/PF21), U602.6 (SCK)
/USB hub/HUB_SPI_D0: R609.1, U601.70 (SPI_D0/~CFG_BC_EN/PF22), U602.5 (SI/SIO0)
/USB hub/HUB_SPI_D1: R611.1, U601.71 (SPI_D1/PF23), U602.2 (SO/SIO1)
/USB hub/HUB_SPI_D2: R612.1, U601.72 (SPI_D2/PF24), U602.3 (~WP/SIO2)
/USB hub/HUB_SPI_D3: R613.1, R614.1, U601.73 (SPI_D3/PF25), U602.7 (HOLD/SIO3)
/USB hub/HUB_TEST1: R602.1, U601.63 (TEST1)
/USB hub/HUB_TEST2: R603.1, U601.64 (TEST2)
/USB hub/HUB_TEST3: R604.1, U601.65 (TEST3)
/USB hub/HUB_UP_TXN_IC: C602.1, U601.92 (USB3UP_TXDM)
/USB hub/HUB_UP_TXP_IC: C601.1, U601.91 (USB3UP_TXDP)
/USB hub/HUB_VBUS_BUF: R632.1, U603.4
/USB hub/HUB_VBUS_DET: R632.2, R633.1, U601.2 (PF30/VBUS_MON_UP)
/USB hub/HUB_VBUS_SNS: D602.2 (A), R625.2, R626.1, U603.2
/USB hub/HUB_XI: C637.1, U601.98 (XTALI/CLK_IN), Y601.1
/USB hub/HUB_XO: C638.1, U601.97 (XTALO), Y601.3
CR_DN: U601.6 (USB2DN_DM1/~PRT_DIS_M1); also elsewhere on the board
CR_DP: U601.5 (USB2DN_DP1/~PRT_DIS_P1); also elsewhere on the board
CR_SS_RXN: U601.11 (USB3DN_RXDM1); also elsewhere on the board
CR_SS_RXP: U601.10 (USB3DN_RXDP1); also elsewhere on the board
CR_SS_TXN: C604.2; also elsewhere on the board
CR_SS_TXP: C603.2; also elsewhere on the board
ETH_DN: U601.35 (USB2DN_DM4/~PRT_DIS_M4); also elsewhere on the board
ETH_DP: U601.34 (USB2DN_DP4/~PRT_DIS_P4); also elsewhere on the board
ETH_SS_RXN: U601.40 (USB3DN_RXDM4); also elsewhere on the board
ETH_SS_RXP: U601.39 (USB3DN_RXDP4); also elsewhere on the board
ETH_SS_TXN: C610.2; also elsewhere on the board
ETH_SS_TXP: C609.2; also elsewhere on the board
GND: C613.2, C614.2, C615.2, C616.2, C617.2, C618.2, C619.2, C620.2, C621.2, C622.2, C623.2, C624.2, C625.2, C626.2, C627.2, C628.2, C629.2, C630.2, C631.2, C632.2, C633.2, C634.2, C635.2, C636.2, C637.2, C638.2, C639.2, C640.2, C641.2, R601.2, R605.2, R606.2, R607.2, R610.2, R611.2, R612.2, R613.2, R615.2, R616.2, R617.2, R618.2, R619.2, R620.2, R621.2, R622.2, R623.2, R626.2, R629.2, R633.2, U601.24 (TESTEN), U601.101 (VSS), U602.4 (VSS), U603.3 (GND), Y601.2 (G), Y601.4 (G); also elsewhere on the board
HUB_DSC_DN: U601.82 (USB2DN_DM5/~PRT_DIS_M5); also elsewhere on the board
HUB_DSC_DP: U601.81 (USB2DN_DP5/~PRT_DIS_P5); also elsewhere on the board
HUB_DSC_SS_RXN: U601.87 (USB3DN_RXDM5); also elsewhere on the board
HUB_DSC_SS_RXP: U601.86 (USB3DN_RXDP5); also elsewhere on the board
HUB_DSC_SS_TXN: C612.2; also elsewhere on the board
HUB_DSC_SS_TXP: C611.2; also elsewhere on the board
HUB_RESET_N: C639.1, D601.2 (A), R624.1, U601.1 (RESET_N); also elsewhere on the board
HUB_SMB_CLK: R627.1, U601.75 (PF26); also elsewhere on the board
HUB_SMB_DAT: R628.1, U601.76 (PF27); also elsewhere on the board
HUB_SMB_PU: R627.2, R628.2, R629.1; also elsewhere on the board
HUB_UP_SS_RXN: U601.95 (USB3UP_RXDM); also elsewhere on the board
HUB_UP_SS_RXP: U601.94 (USB3UP_RXDP); also elsewhere on the board
HUB_UP_SS_TXN: C602.2; also elsewhere on the board
HUB_UP_SS_TXP: C601.2; also elsewhere on the board
LAPTOP_USB_DN: U601.90 (USB2UP_DM); also elsewhere on the board
LAPTOP_USB_DP: U601.89 (USB2UP_DP); also elsewhere on the board
MCU_USB_DN: U601.41 (USB2DN_DM6/~PRT_DIS_M6); also elsewhere on the board
MCU_USB_DP: U601.42 (USB2DN_DP6/~PRT_DIS_P6); also elsewhere on the board
RAILS_PG: D601.1 (K); also elsewhere on the board
USBA1_DN: U601.15 (USB2DN_DM2/~PRT_DIS_M2); also elsewhere on the board
USBA1_DP: U601.14 (USB2DN_DP2/~PRT_DIS_P2); also elsewhere on the board
USBA1_OCS_N: R630.2; also elsewhere on the board
USBA1_PWR_EN: R630.1, U601.59 (PF16); also elsewhere on the board
USBA1_SS_RXN: U601.20 (USB3DN_RXDM2); also elsewhere on the board
USBA1_SS_RXP: U601.19 (USB3DN_RXDP2); also elsewhere on the board
USBA1_SS_TXN: C606.2; also elsewhere on the board
USBA1_SS_TXP: C605.2; also elsewhere on the board
USBA2_DN: U601.28 (USB2DN_DM3/~PRT_DIS_M3); also elsewhere on the board
USBA2_DP: U601.27 (USB2DN_DP3/~PRT_DIS_P3); also elsewhere on the board
USBA2_OCS_N: R631.2; also elsewhere on the board
USBA2_PWR_EN: R631.1, U601.58 (PF15); also elsewhere on the board
USBA2_SS_RXN: U601.33 (USB3DN_RXDM3); also elsewhere on the board
USBA2_SS_RXP: U601.32 (USB3DN_RXDP3); also elsewhere on the board
USBA2_SS_TXN: C608.2; also elsewhere on the board
USBA2_SS_TXP: C607.2; also elsewhere on the board
VBUS_LAPTOP: R625.1; also elsewhere on the board

Notes on the sheet:
1. USB7206C USB 3.2 Gen2 hub, VQFN-100 12x12 (EP = VSS, via array to GND planes)
2. HUB TX AC-COUPLING 220 nF 0402 X7R in series with every hub SS TX (upstream + 5 downstream).
Hub RX pairs have no caps here: the transmitting chip's side (TUSB1064/TUSB1046/GL3224/RTL8156/USB-A sheet) provides them.
Place caps within ~5 mm of the hub pins, symmetric per pair, cut the reference plane under the 0402 pads (L2 void) for 10G.
3. DECOUPLING VDD33 x8 pins, VCORE x9 pins: 100 nF per pin at the pin, plus 4.7 uF + 1 nF per rail (DS fig. 4-1).
VCORE ~1.31 A (10G upstream + 5x 10G ports: 410 + 5*179 mA), VDD33 ~0.09 A -> ~1.8 W total; theta-JA 19 C/W (2S2P) -> ~+35 K.
+1V15 bulk 4x22 uF sits at the TPS62933P (power_rails); route +1V15 as a pour on L4 under the hub.
4. CLOCK / BIAS / TEST / STRAPS
Straps are latched at POR / RESET_N rising edge (hold >= 1 ms after). Config 3 (STRAP2 200k PD, STRAP1 10k PD) is the
only valid USB7206C mode: PF26/27 = SMBus slave, PF15/16 = PRT_CTL3/2, PF30 = VBUS_DET, PF18/31 = I2C master (unused).
PF3-7 (I2S), PF18/31 (I2C master), PF19 (MIC_DET), PF29 (GPIO93): unused -> 100k PD. PF8/9 NC. PRT_CTL1/4/5/6 float.
CFG_NON_REM 200k PU = port 1 non-removable; CFG_BC_EN 10k PU = BC1.2 on ports 1-3. RP2350 refines both over SMBus
(non-removable 1/4/6, BC on 2/3 only) when it is alive; with the RP2350 dead the strap defaults are safe.
5. RESET / VBUS_DET / SMBUS
RESET_N = HUB_RESET_N (RP2350 open-drain) AND RAILS_PG (TPS62933P PG, open drain, 100k on power_rails) via D601.
Hub held in standby until +1V15 is in regulation (implies +3V3 up); 10k pull-up then releases it. trst >= 5 us.
VBUS_DET (PF30): VBUS_LAPTOP -> 47k/68k (x0.591) + BAT54WS clamp to +3V3 -> HUB_VBUS_SNS -> 74LVC1G17 (+3V3, Schmitt,
5.5 V-tolerant input) -> 15k/49.9k -> PF30. Sense node: 4.4 V -> 2.60 V (> VT+ max 2.0 V), 28 V -> ~3.6 V clamp (OK for
the LVC input), vSafe0V 0.8 V -> 0.47 V (< VT- min 0.8 V). PF30 high = +3V3 x 0.769 = 2.46-2.64 V for +3V3 3.20-3.43 V
(<= 2.7 V checklist 5.1, > VIH 2.1 V); 11k/49.9k from the checklist would give 2.73 V at our 3.33 V rail -> 15k.
Buffer powered from +3V3 = same rail as VDD33 -> VBUS_DET can never rise before VDD33.
VBUS present = laptop attached (deck sources VBUS only after attach). Limitation (review data #6): VBUS also exists for
a powered-off laptop / charge-only cable -> hub waits as CDP, USB-A get no VBUS until FORCE_EN (firmware).
VBUS_DET = 0 (no laptop): BC1.2 ports run as DCP; VBUS_DET = 1: CDP once the host powers the port.
SMBus slave addr 0x2D. Pull-ups only when HUB_SMB_PU (RP2350 GPIO) is high -> hub enters CFG_SMBUS and waits for
the RP2350's config + USB_ATTACH_WITH_SMBUS (AA56h). HUB_SMB_PU low/floating (RP2350 off, BOOTSEL, broken FW):
no pull-ups seen -> hub boots from ROM+straps+OTP immediately -> RP2350 BOOTSEL (UF2) still enumerates on port 6.
Firmware: SMB_PU high -> RESET_N low >= 5 us -> release -> wait >= 40 ms -> config -> AA56h. No other pull-ups on this bus.
6. USB-A PORT POWER PRT_CTLx = combined power-enable output + overcurrent input (DS 8.2)
USB-A #1 = hub port 2 (PRT_CTL2, PF16), USB-A #2 = hub port 3 (PRT_CTL3, PF15). Port on: pin = input + internal ~50k
pull-up (EN high), switch FAULT# (open drain) pulls it low = overcurrent; port off: hub drives it low.
USBAx_PWR_EN and USBAx_OCS_N are therefore the SAME node (0R ties, R630/R631). Do NOT add an external pull-up.
usb_a sheet: TPS2553 EN = PWR_EN OR FORCE_EN (gate input, high-Z), FAULT# open-drain -> OCS_N.
Embedded ports (1 GL3224, 4 RTL8156, 5 TUSB1046/PMG1, 6 RP2350): PRT_CTL floats (internal pull-up, never reads OC).
7. OPTIONAL SPI FLASH (DNP) only for Microchip-supplied custom firmware; ROM + straps + SMBus/OTP is the plan
Hub boots from flash only if it holds a valid image with the '2DFU' signature at 0x3FFFA; a blank flash -> ROM boot.
With the flash fitted the CE#/D0 strap resistors stay (they are read before the flash is probed). Fit R614 (D3 10k PU)
and remove R613 (D3 PD) so HOLD# is inactive. Flash images come only from Microchip -> not planned for odock-10.
8. PORT MAP (logical = physical on USB7206C) hub side (chip rotated with pins 76-100 toward the back edge)
UP : laptop via TUSB1064 top side, center HUB_UP_SS_*, LAPTOP_USB_DP/DN

Schematic: display_ui.kicad_sch, odock-10 — Display & user interface

Parts:
C1101: 4.7u; C_0402_1005Metric; LCSC C23733
C1102, C1105, C1106, C1107: 100n; C_0402_1005Metric; LCSC C1525
C1103, C1104, C1108, C1109: 10n; C_0402_1005Metric; LCSC C15195
D1101, D1102, D1103, D1104: TPD4E02B04; USON-10_L2.5-W1.0-P0.50-BL; MPN TPD4E02B04DQAR; LCSC C106794
F1101, F1102: 0.5A; Fuse_1206_3216Metric; LCSC C75464
J1101: USER GPIO; PinHeader_2x08_P2.54mm_Vertical
J1102: QWIIC; CONN-SMD_4P-P1.00_SM04B-SRSS-TB-LF-SN; MPN SM04B-SRSS-TB(LF)(SN); LCSC C160404
J1103: LCD FPC; FFC-SMD_12P-P0.50_FH34SRJ-12S-0.5SH; MPN FH34SRJ-12S-0.5SH(50); LCSC C424659
Q1101: AO3400A; SOT-23; LCSC C20917
R1101: 39; R_1206_3216Metric; LCSC C22198
R1102: 100; R_0402_1005Metric; LCSC C25076
R1103: 100k; R_0402_1005Metric; LCSC C25741
R1104, R1105, R1114, R1115: 10k; R_0402_1005Metric; LCSC C25744
R1106, R1107, R1108, R1109, R1110, R1111, R1112, R1113: 220; R_0402_1005Metric; LCSC C25091
SW1101: BTN_A; KEY-SMD_SKRTLAE010; MPN SKRTLAE010; LCSC C110293
SW1102: BTN_B; KEY-SMD_SKRTLAE010; MPN SKRTLAE010; LCSC C110293
U1101: HS20HS072RX; LCD_HS20HS072RX_Outline; MPN HS20HS072RX; LCSC C5329582; not fitted

Connections:
+3V3: C1101.1, C1102.1, F1102.1, J1103.4, J1103.5, R1104.2, R1105.2; also elsewhere on the board
+5V: F1101.1, R1101.1; also elsewhere on the board
/Display & UI/+3V3_USR: C1106.1, C1107.1, F1102.2, J1101.2, J1102.2
/Display & UI/+5V_USR: C1105.1, F1101.2, J1101.1
/Display & UI/BL_GATE: Q1101.1 (G), R1102.2, R1103.1
/Display & UI/HDR_A0: D1103.1 (IO1), J1101.13, R1114.2
/Display & UI/HDR_A1: D1103.2 (IO2), J1101.14, R1115.2
/Display & UI/HDR_P0: D1101.1 (IO1), J1101.3, R1106.2
/Display & UI/HDR_P1: D1101.2 (IO2), J1101.4, R1107.2
/Display & UI/HDR_P2: D1101.4 (IO3), J1101.5, R1108.2
/Display & UI/HDR_P3: D1101.5 (IO4), J1101.6, R1109.2
/Display & UI/HDR_P4: D1102.1 (IO1), J1101.9, R1110.2
/Display & UI/HDR_P5: D1102.2 (IO2), J1101.10, R1111.2
/Display & UI/HDR_P6: D1102.4 (IO3), J1101.11, R1112.2
/Display & UI/HDR_P7: D1102.5 (IO4), J1101.12, R1113.2
/Display & UI/LCD_BL_A: J1103.3, R1101.2
/Display & UI/LCD_BL_K: J1103.2, Q1101.3 (D)
BTN_A_N: C1103.1, R1104.1, SW1101.2; also elsewhere on the board
BTN_B_N: C1104.1, R1105.1, SW1102.2; also elsewhere on the board
GND: C1101.2, C1102.2, C1103.2, C1104.2, C1105.2, C1106.2, C1107.2, C1108.2, C1109.2, D1101.3 (GND), D1101.8 (GND), D1102.3 (GND), D1102.8 (GND), D1103.3 (GND), D1103.8 (GND), D1104.3 (GND), D1104.8 (GND), J1101.7, J1101.8, J1101.15, J1101.16, J1102.1, J1102.5, J1102.6, J1103.1, J1103.12, J1103.13, J1103.14, Q1101.2 (S), R1103.2, SW1101.1, SW1101.3, SW1101.4, SW1101.5, SW1102.1, SW1102.3, SW1102.4, SW1102.5; also elsewhere on the board
HDR_ADC0: C1108.1, R1114.1; also elsewhere on the board
HDR_ADC1: C1109.1, R1115.1; also elsewhere on the board
HDR_GPIO0: R1106.1; also elsewhere on the board
HDR_GPIO1: R1107.1; also elsewhere on the board
HDR_GPIO2: R1108.1; also elsewhere on the board
HDR_GPIO3: R1109.1; also elsewhere on the board
HDR_GPIO4: R1110.1; also elsewhere on the board
HDR_GPIO5: R1111.1; also elsewhere on the board
HDR_GPIO6: R1112.1; also elsewhere on the board
HDR_GPIO7: R1113.1; also elsewhere on the board
I2C_EXT_SCL: D1104.2 (IO2), J1102.4; also elsewhere on the board
I2C_EXT_SDA: D1104.1 (IO1), J1102.3; also elsewhere on the board
LCD_BL_PWM: R1102.1; also elsewhere on the board
LCD_CS_N: J1103.11; also elsewhere on the board
LCD_DC: J1103.10; also elsewhere on the board
LCD_MOSI: J1103.8; also elsewhere on the board
LCD_RST_N: J1103.7; also elsewhere on the board
LCD_SCK: J1103.9; also elsewhere on the board

Notes on the sheet:
1. LCD HS20HS072RX 2.0in IPS 240x320 (ST7789), SPI 4-wire, 3.3 V logic
FPC pinout (datasheet sec. 6): 1 GND, 2 CS, 3 RS (D/C), 4 SCL, 5 SDA (MOSI), 6 RST, 7 NC, 8 IOVCC, 9 VCI, 10 LED-A, 11 LED-K, 12 GND.
Interface is hard-wired to 4-wire SPI inside the module (no IM straps on the FPC); write-only (no MISO), up to 62.5 MHz.
VCI 2.4-3.3 V / IOVCC 1.65-3.3 V: both on +3V3 = 3.33 V nom (~3.36 V max): accepted known deviation from the 3.3 V
recommended max (abs max 4.6 V). Retrimming +3V3 to 3.30 V (power_rails) would remove it.
MECHANICAL: U1101 is DNP (hand-fitted after assembly); its footprint is the panel outline. J1103 = Hirose FH34SRJ (dual contact,
1.0 mm high, 0.3 mm FPC) UNDER the panel, opening toward the tail edge, 14.5 mm inside it. The tail folds 180 deg under the panel
(contacts face the PCB), so PANEL PIN n -> J1103 PIN 13-n. Foam tape >= 1.5 mm with a window over J1103 and the tail.
2. BACKLIGHT 4 white LEDs in parallel, Vf 3.0 V typ (2.8-3.2) @ 80 mA max -> from +5V, 39R, low-side PWM
Not from +3V3: 0.1-0.5 V headroom over Vf would make the current depend on LED Vf. 55 mA typ (+5V 5.13 V) -> ~0.28 W.
Worst case: bus-powered +5V = laptop VBUS up to 5.5 V: (5.5-2.8)/39 = 69 mA (72 mA at Vf 2.7 V hot) < 80 mA abs max.
Min (4.75 V, Vf 3.2) = 40 mA. PWM does not reduce the peak current, so R1101 alone must keep it under 80 mA.
PWM: LCD_BL_PWM (GPIO25, PWM4 B) at >= 20 kHz (inaudible), 0-100 %. Firmware dims after inactivity.
3. USER BUTTONS side-push (actuator overhangs the front edge), active low
Button A: per-port forced-5V 'charge mode' toggle; button B: LCD page/select (firmware-defined, remappable).
Place on the front edge with the actuator 0.3-0.5 mm past the board outline. Footprint has 2 x 0.9 mm guide-boss holes.
4. USER GPIO HEADER 2x8 2.54 mm, UNPOPULATED (in_bom no); series R + ESD + fuses populated
Pinout (silkscreen, top and back): 1 5V 2 3V3 | 3 G12 4 G13 | 5 G14 6 G15 | 7 GND 8 GND
9 G16 10 G17 | 11 G18 12 G19 | 13 A4(G44) 14 A5(G45) | 15 GND 16 GND
HDR_P0..7 = RP2350 GPIO12..19: contiguous (PIO). FREE for the header: SPI1 (12-15), PWM6/7/0/1, PIO2, HSTX (not DVI:
220R + ESD break TMDS). UART0 (debug), SPI0 (LCD), I2C0 (I2C_PD) and I2C1 (I2C_SYS) are already taken.
3.3 V LOGIC ONLY. 220R + ESD (TPD4E02B04 VRWM 3.6 V): 5 V is abuse, not a feature, even though the FT pads survive it.
A0/A1 (ADC4/5) via 10k + 10 nF: 0-3.3 V, not fault tolerant. 5V/3V3 pins are outputs (do not back-feed the deck).
5. QWIIC / STEMMA QT JST SH 4-pin, I2C_EXT (PIO I2C, 4.7k pull-ups on mcu sheet), 3.3 V
Qwiic power shares the fused +3V3_USR with the header. Bus is independent of I2C_SYS (no risk to the sensors/PD bus).

Schematic: pd_pmg1.kicad_sch, odock-10 — PD controller PMG1-S3 (laptop + downstream USB-C)

Parts:
C401, C405, C408, C412, C413: 1u; C_0402_1005Metric; LCSC C52923
C402, C404, C406, C407, C409, C410, C411, C420: 100n; C_0402_1005Metric; LCSC C1525
C403: 4.7u; C_0603_1608Metric; LCSC C19666
C414, C415: 100n/50V; C_0603_1608Metric; LCSC C14663
C416, C417, C418, C419: 390p; C_0402_1005Metric; LCSC C282239
C421, C422: 10u; C_0805_2012Metric; LCSC C15850
JP401, JP402, JP403: SWD_CUT; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
Q401: AO3400A; SOT-23; LCSC C20917
Q402: AO4842; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C427016
R401: 4.7k; R_0402_1005Metric; LCSC C25900
R402, R403, R404: 10k; R_0402_1005Metric; LCSC C25744
R405, R406, R407, R408, R409, R410, R411, R412: 100k; R_0402_1005Metric; LCSC C25741
R413, R414: 1k; R_0402_1005Metric; LCSC C11702
R415: 5m; R_1206_3216Metric; MPN RLM12FTCMR005; LCSC C316225
TP401: SWDIO_L; TestPoint_Pad_D1.0mm
TP402: SWCLK_L; TestPoint_Pad_D1.0mm
TP403: XRES; TestPoint_Pad_D1.0mm
TP404: UART_TX; TestPoint_Pad_D1.0mm
TP405: UART_RX; TestPoint_Pad_D1.0mm
TP406: GND; TestPoint_Pad_D1.0mm
U401: CYPM1321-97BZXI; BGA-97_L6.0-W6.0-P0.50-TL_CYPD8225-97BZXIT; MPN CYPM1321-97BZXIT; LCSC C20190828

Connections:
+3V3: C401.1, C402.1, Q401.1 (G), R402.2, R404.1, U401.B14 (VSYS); also elsewhere on the board
+5V: C412.1, C413.1, C421.1, R415.1, U401.C15 (CSP_P1), U401.L1 (VCONN_Source_P1), U401.L2 (VCONN_Source_P1), U401.L14 (VCONN_Source_P0), U401.L15 (VCONN_Source_P0); also elsewhere on the board
/PD controller/DS_FETD: Q402.5 (D2), Q402.6 (D2), Q402.7 (D1), Q402.8 (D1)
/PD controller/DS_GIN: Q402.2 (G1), U401.P2 (VBUS_IN_CTRL_P1)
/PD controller/DS_GOUT: Q402.4 (G2), U401.P1 (VBUS_OUT_CTRL_P1)
/PD controller/DS_SRC: Q402.1 (S1), R415.2, U401.C14 (CSN_P1), U401.R2 (VBUS_IN_NGDO_P1)
/PD controller/HPD0_OUT: R414.1, U401.K4 (P1.3)
/PD controller/HPD1_OUT: R413.1, U401.G14 (P7.1)
/PD controller/P3V3_SNS: R404.2, R405.1, U401.A9 (P7.5)
/PD controller/PMG1_SWCLK_L: JP403.2 (B), TP402.1, U401.P3 (P1.1)
/PD controller/PMG1_SWDIO_L: JP402.2 (B), TP401.1, U401.R3 (P1.2)
/PD controller/PMG1_UART_RX: TP405.1, U401.B5 (P2.3)
/PD controller/PMG1_UART_TX: TP404.1, U401.A3 (P2.2)
/PD controller/PMG1_VCCD: C411.1, U401.D10 (VCCD)
/PD controller/PMG1_XRES: C420.1, Q401.3 (D), R401.1, TP403.1, U401.E14 (XRES)
/PD controller/XRES_RP: JP401.2 (B), Q401.2 (S), R402.1
DS_CC1: C418.1, U401.N1 (CC1_P1), U401.N2 (CC1_P1); also elsewhere on the board
DS_CC2: C419.1, U401.J1 (CC2_P1), U401.J2 (CC2_P1); also elsewhere on the board
DS_HPD: R413.2, U401.M10 (P1.4); also elsewhere on the board
EXT_PWR_PRESENT: R406.1, U401.G15 (P7.0); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, C416.2, C417.2, C418.2, C419.2, C420.2, C421.2, C422.2, R405.2, R406.2, R407.2, R408.2, R409.2, R410.2, R411.2, R412.2, TP406.1, U401.F8 (VSS), U401.F10 (VSS), U401.F12 (VSS), U401.H8 (VSS), U401.H10 (VSS), U401.K8 (VSS), U401.K10 (VSS); also elsewhere on the board
I2C_PD_INT_N: R403.1, U401.B9 (P7.6); also elsewhere on the board
I2C_PD_SCL: U401.E15 (P4.0); also elsewhere on the board
I2C_PD_SDA: U401.D12 (P4.1); also elsewhere on the board
LAPTOP_CC1: C416.1, U401.N14 (CC1_P0), U401.N15 (CC1_P0); also elsewhere on the board
LAPTOP_CC2: C417.1, U401.J14 (CC2_P0), U401.J15 (CC2_P0); also elsewhere on the board
LAPTOP_OVP_N: U401.B11 (P7.4); also elsewhere on the board
LAPTOP_SNK_EN: U401.R8 (P0.0); also elsewhere on the board
LAPTOP_SRC_EN: U401.B7 (P2.6); also elsewhere on the board
MUX_DS_CTL0: R410.1, U401.B1 (P3.3); also elsewhere on the board
MUX_DS_CTL1: R411.1, U401.D4 (P3.4); also elsewhere on the board
MUX_DS_FLIP: R412.1, U401.C1 (P3.7); also elsewhere on the board
MUX_UP_CTL0: R407.1, U401.A1 (P3.0); also elsewhere on the board
MUX_UP_CTL1: R408.1, U401.B3 (P3.1); also elsewhere on the board
MUX_UP_FLIP: R409.1, U401.C2 (P3.2); also elsewhere on the board
PDIN_PRESENT: U401.A14 (P7.2); also elsewhere on the board
PMG1_SWCLK: JP403.1 (A); also elsewhere on the board
PMG1_SWDIO: JP402.1 (A); also elsewhere on the board
PMG1_VDDD: C403.1, C404.1, C405.1, C406.1, C407.1, C408.1, C409.1, C410.1, R401.2, R403.2, U401.B8 (VDDIO), U401.D6 (VDDA), U401.D8 (VDDD), U401.F6 (VDDA), U401.H12 (VDDIO); also elsewhere on the board
PMG1_XRES_N: JP401.1 (A); also elsewhere on the board
UP_HPD: R414.2; also elsewhere on the board
VBB_EN: U401.A2 (P2.0); also elsewhere on the board
VBB_PG: U401.B13 (P7.3); also elsewhere on the board
VBB_VSEL0: U401.B2 (P2.1); also elsewhere on the board
VBB_VSEL1: U401.A7 (P2.4); also elsewhere on the board
VBB_VSEL2: U401.A5 (P2.5); also elsewhere on the board
VBUS_DS: C415.1, C422.1, Q402.3 (S2), U401.H14 (VBUS_C_P1), U401.R1 (VBUS_OUT_NGDO_P1); also elsewhere on the board
VBUS_LAPTOP: C414.1, U401.A15 (CSN_P0), U401.H15 (VBUS_C_P0); also elsewhere on the board
VBUS_LSW: U401.B15 (CSP_P0); also elsewhere on the board

Notes on the sheet:
PMG1-S3 DUAL-PORT PD CONTROLLER (CYPM1321-97BZXI = CYPM1322 + dead-battery Rd on CC) Port 0 = laptop USB-C: DRP. Source 5-28 V EPR 140 W via power_laptop (VBB_EN, VBB_VSEL2..0, VBB_PG, LAPTOP_SRC_EN); sink in bus-powered mode (LAPTOP_SNK_EN). Data UFP, DP Alt Mode UFP_D -> TUSB1064. The port-0 powe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
2. PMG1 SUPPLY (dead-deck capable) VSYS = +3V3 (deck powered): VDDD = VSYS - 0.1 V. Dead deck (no +3V3): the internal 28 V VBUS regulator powers VDDD (3.0-3.65 V, 60 mA max) from VBUS_C_P0 (laptop) or VBUS_C_P1. VSYS has priority. VDDIO and VDDA tied to VDDD (PMG1_VDDD) so EVERY GPIO works in a dea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
3. CC LINES 390 pF to GND on each CC (Infineon reference; within cReceiver 200-600 pF). CC pins are 6 V abs max: LAPTOP_CC1/2 must arrive through CC OVP (TPD4S480) on usbc_muxes.
4. RESET + SWD (RP2350 = SWD programmer; default-closed solder jumpers, cut to isolate) XRES: 4.7k pull-up to VDDD + 100 nF (Infineon Fig. 12). The RP2350 side goes through a pass FET (gate = +3V3, BSS138-style): with +3V3 absent (dead-deck boot) the unpowered RP2350 pin cannot clamp XRES low and h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
5. HOST INTERFACE (RP2350) I2C_PD on SCB0 (P4.0 SCL / P4.1 SDA: the only fail-safe I2C pins, same SCB as the dock example's HPI). PMG1 target address 0x42 (firmware-defined, CCGx HPI alternate address; TPS26750 = 0x21 on the same bus). Bus pull-ups on the MCU sheet (+3V3). I2C_PD_INT_N: P7.6 (B9), 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
6. MUX CONTROL (TUSB1064 / TUSB1046 in GPIO mode, I2C_EN = 0) Port 0 -> TUSB1064: CTL0 = USB3 on, CTL1 = DP on, FLIP = CC orientation (P3.0/P3.1/P3.2). Port 1 -> TUSB1046: CTL0, CTL1, FLIP (P3.3/P3.4/P3.7). 100k pull-downs hold CTL0/CTL1/FLIP low while PMG1 is in reset/unpowered. NOTE: both muxes s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
7. PORT 1 (DOWNSTREAM) VBUS SOURCE +5V -> 5 mOhm (CSP_P1/CSN_P1) -> AO4842 back-to-back -> VBUS_DS Gate-driver pair 1 (VBUS_IN_CTRL_P1 = supply-side FET, VBUS_OUT_CTRL_P1 = connector-side FET), common drain: blocks both directions when off (a phone/charger on the port cannot back-feed +5V). Gate ov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

Board: 6 copper layers, 801 parts (493 on the bottom side), 531 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: MountingHole_3.2mm_M3_Pad_Via
